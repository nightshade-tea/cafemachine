## src/hw/cafe/Kconfig
```kconfig
config CAFE
    bool
    default y if TEST_DEVICES
    depends on PCI && MSI_NONBROKEN
```
